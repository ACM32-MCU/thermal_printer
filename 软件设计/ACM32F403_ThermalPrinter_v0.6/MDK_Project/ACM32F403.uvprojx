# Keil uVision project ACM32F403.uvprojx, settings and files
target ThermalPrinter (6160000::V6.16::ARMCLANG)
  device: ACM32F403RCT7 Aisinochip
  pack: Aisinochip.ACM32F4.1.0.1
  cpu: IRAM(0x20000000,0x18000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: ACM32F4 +hex
  AfterMake: fromelf.exe --bin --output ./Out_Files/ACM32F4.bin ./Objects/ACM32F4.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3
  c include: ..\Source_Code\APP;..\Source_Code\Core_Drivers\ALG_Driver\Src;..\Source_Code\Core_Drivers\ALG_Driver\Inc;..\Source_Code\Core_Drivers\CMSIS;..\Source_Code\Core_Drivers\Device;..\Source_Code\Core_Drivers\HAL_Driver\Inc;..\Source_Code\Core_Drivers\HAL_Driver\Src;..\Source_Code\Middleware;..\Source_Code\IC_Driver
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group CoreDriver/CMSIS
    ../Source_Code/Core_Drivers/CMSIS/: core_cm33.h
  group CoreDriver/Device
    ../Source_Code/Core_Drivers/Device/: ACM32F4.h Startup_ACM32F4.s System_Accelerate.h System_Accelerate.lib System_ACM32F4.c System_ACM32F4.h
  group CoreDriver/HAL
    ../Source_Code/Core_Drivers/HAL_Driver/Src/: HAL_ADC.c HAL_EFlash.c HAL_FSUSB.c HAL_GPIO.c HAL_SPI.c HAL_TIMER.c HAL_Uart.c HAL_DMA.c HAL_EFlash_EX.lib HAL_EXTI.c
  group SourceCode/APP
    ../Source_Code/APP/: main.c printer.c font.c debug.c power_manage.c led.c word_stock.c ble.c
    ../Source_Code/Middleware/: middle.c middle_isr.c
  group SourceCode/IC_Driver
    ../Source_Code/IC_Driver/: IC_W25Qxx.c
