# Keil uVision project ACM32F403.uvprojx, settings and files
target ThermalPrinter (6160000::V6.16::ARMCLANG)
  device: ARMCM33_DSP_FP ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ESEL ELITTLE
  output: ACM32F4 +hex
  AfterMake: fromelf.exe --bin --output ./Out_Files/ACM32F4.bin ./Objects/ACM32F4.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3
  c include: ..\Source_Code\APP;..\Source_Code\Core_Drivers\ALG_Driver\Src;..\Source_Code\Core_Drivers\ALG_Driver\Inc;..\Source_Code\Core_Drivers\CMSIS;..\Source_Code\Core_Drivers\Device;..\Source_Code\Core_Drivers\HAL_Driver\Inc;..\Source_Code\Core_Drivers\HAL_Driver\Src;..\Source_Code\Middleware;..\Source_Code\IC_Driver
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  group CoreDriver/CMSIS
    ../Source_Code/Core_Drivers/CMSIS/: core_cm33.h
  group CoreDriver/Device
    ../Source_Code/Core_Drivers/Device/: ACM32F4.h Startup_ACM32F4.s System_Accelerate.h System_Accelerate.lib System_ACM32F4.c System_ACM32F4.h
  group CoreDriver/HAL
    ../Source_Code/Core_Drivers/HAL_Driver/Src/: HAL_ADC.c HAL_EFlash.c HAL_FSUSB.c HAL_GPIO.c HAL_SPI.c HAL_TIMER.c HAL_Uart.c HAL_DMA.c HAL_EFlash_EX.lib
  group SourceCode/APP
    ../Source_Code/APP/: main.c printer.c font.c debug.c power_manage.c led.c word_stock.c usb_app.c usb_desc.c app.c
    ../Source_Code/Middleware/: middle.c middle_isr.c
  group SourceCode/IC_Driver
    ../Source_Code/IC_Driver/: IC_W25Qxx.c
